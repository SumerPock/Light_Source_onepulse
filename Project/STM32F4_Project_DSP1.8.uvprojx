# Keil uVision project STM32F4_Project_DSP1.8.uvprojx, settings and files
target CL202 (5060960::V5.06 update 7 (build 960)::.\AC506u7)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ARM_Project_Ver2.1.1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\CMSIS;..\Library\inc;..\User\inc;..\SEGGER\RTT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/src/: main.c gpio.c stm32f4xx_it.c i2c.c usart.c lcd.c delay.c ui.c flash.c fsmc.c RandomCode.c tim.c soft_i2c.c soft_i2c_lm75b.c bsp.c ring_buffer.c ring_buffer_chapter.c bsp_uart.c bsp_uart_dma.c bsp_ui_showp_foundation.c bsp_key.c bsp_key_oc.c bsp_mode.c EXIT.c
  group CMSIS
    ../System/: startup_stm32f407xx.s
    ../User/src/: system_stm32f4xx.c
  group STM32F4xx Library
    ../Library/src/: stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_i2c.c misc.c stm32f4xx_flash.c stm32f4xx_tim.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_syscfg.c
  group Doc
    ../User/Doc/: readme.txt
  group SEGGER
    ../SEGGER/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
